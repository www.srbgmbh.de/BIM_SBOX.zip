Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: b0a8760c-85e2-4ac0-9823-b4327edb50ba, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Gemeinsam genutzte Koordinaten]
File name: SBOX - V2A - Decke.ifc
Time: 2024-06-28T09:08:05+01:00
Written by: ODA SDAI 24.12
Made in: Autodesk Revit 25.1.0.44 (DEU) - IFC 25.1.0.44

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 0 m

# IfcFlowTerminal: SBOX - V2A - Decke:SBOX V2A 300 DM LED 6W - 230, SBOX - V2A - Decke:SBOX V2A 300 DM LED 6W - 230:2518127
In: Default
Type - Material: Stahl - poliert
Type - Pset_ElementShading - Color: white
Pset_DistributionFlowElementCommon - Reference: SBOX V2A 300 DM LED 6W - 230; sets with these values: 2
