Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: edf8dcd1-b004-4946-9314-4c43883f3718, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Gemeinsam genutzte Koordinaten]
File name: SBOX - Galvanisierter Stahl - Wand.ifc
Time: 2024-06-26T15:05:49+01:00
Written by: ODA SDAI 24.12
Made in: Autodesk Revit 25.1.0.44 (DEU) - IFC 25.1.0.44

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 0 m

# IfcFlowTerminal: SBOX - Galvanisierter Stahl - Wand:SBOX 300 WM LED 6W - 230, SBOX - Galvanisierter Stahl - Wand:SBOX 300 WM LED 6W - 230:2518124
In: Default
Type - Material: RAL 9016
Type - Pset_ElementShading - Color: white
Pset_DistributionFlowElementCommon - Reference: SBOX 300 WM LED 6W - 230; sets with these values: 2
